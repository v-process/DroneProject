<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32F103RET6_Sub.ewp</path>
  </project>
  <batchBuild/>
</workspace>


